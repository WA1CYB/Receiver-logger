options:
  parameters:
    author: WA1CYB
    comment: /home/ray/prefix/gr38/share/gnuradio/themes/dark.qss
    description: Logging Receiver ( AM, NBFM, WBFM, USB, LSB )
    generate_options: qt_gui
    id: log_rcv
    output_language: python
    title: Logging Receiver
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    min_len: '2000'
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {state: disabled}
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: avg_count
  id: variable
  parameters:
    comment: 2 samples per second 384k/32 /6000
    value: 6000*2
  states: {}
- name: avg_count_dB
  id: variable
  parameters:
    value: 20*np.log10(avg_count)
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: int(24e3)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      11e9
      NWS:
      162550000
      162475000
      162525000
      162450000

      DTV Carrier
      500309441    use  500313241  or  500314141

      462.5625MHZ   use  462564900
    gui_hint: 0,0,1,1
    label: RX Frequency-Hz
    min_len: '2000'
    start: 25e6*1+(162550000-50000)*0
    step: '100'
    stop: 1.1e9*1+(162550000+50000)*0
    value: 500313241*0+(146955000+900)*0+462564900*1
  states: {}
- name: ft1_atten
  id: variable_qtgui_range
  parameters:
    comment: '-119 dB ~~ -119 dBm'
    gui_hint: 9,0,1,1
    label: '"Input Signal Reduction - dB"'
    min_len: '2000'
    start: '-134'
    step: '0.5'
    stop: '0'
    value: 1*(-134+15)
    widget: counter
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Set RF Gain Max as a f(SDR type)
    gui_hint: 0,2,1,1
    label: RX Gain
    start: '0.0'
    step: '0.5'
    stop: '49'
    value: '30'
  states: {}
- name: gps_sig_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: '"Offset for logging in dB"'
    min_len: '2000'
    start: '-40'
    step: '0.5'
    stop: '150'
    value: '39'
  states: {}
- name: ip_adr_in
  id: variable
  parameters:
    comment: |-
      "192.168.0.123"
      "127.0.0.1"
    value: '"127.0.0.1"'
  states: {}
- name: lsb_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 2.5e3
    low_cutoff_freq: '10'
    samp_rate: baseband_rate
    type: band_pass
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,3,1,1
    label: Demodulation Type
    label0: AM(SYNC)
    label1: WBFM
    label2: USB
    label3: LSB
    label4: NBFM
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '4'
    widget: radio_buttons
  states: {}
- name: port_in
  id: variable
  parameters:
    value: '2948'
  states: {}
- name: probe_variable
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '35'
    value: '0'
  states: {}
- name: rcvr_file_name
  id: variable
  parameters:
    comment: |-
      rcvr_file_name
      log_my_rcvr_gps.txt
      "~/Desktop/log_my_rcvr_gps.txt"
    value: '"log_my_rcvr_gps.csv"'
  states: {}
- name: rit
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Linear Fine Tune-Hz
    min_len: '2000'
    start: '-5000'
    step: '1'
    stop: '5000'
    value: '-811'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(32*48e3)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    start: '0.0'
    step: '0.025'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1.0e10
    rate: '1e-3'
    reference: '0.300'
    type: complex
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: probe_variable
    type: float
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: 0.000000178*45.254833996
    comment: |-
      -135 = 0.000000178
      45.254833996 = sqrt(2048) FFT Gain
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_fastnoise_source_x_1
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: baseband_rate
    comment: |-
      assuming 300->3000 pre-emphasis
      Tau = 1/(2*PI*300) = 5.30516476973e-4


      2*(3.75+5.5)= 18.5 kHz
      2*(3.75+7.5)= 22.5 kHz

      7.5 max deviations compensates for being off frequency on the uplink
    max_dev: 5e3
    quad_rate: baseband_rate
    tau: '5.305e-4'
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: (10*2*3.14159)/baseband_rate
    min_freq: (-10*2*3.14159)/baseband_rate
    w: 3.14159/200
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: 16*1
    comment: Set up for audio at 20 kHz or 24 kHz
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: AM Syncronus
    decim: '1'
    gain: '1'
    high_cutoff_freq: baseband_rate/2.5
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_fff
    width: '60'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: USB  Tuned on Frequency
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.5e3
    low_cutoff_freq: '10'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-20'
    low_cutoff_freq: '-3.2e3'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '15'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 3.2e3
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '15'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: gps_sig_offset
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '2500'
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(avg_count)
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_ft1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(ft1_atten/20.)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_ft1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(ft2_atten/20.)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: carrier added
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: RX_power_offset_dB
    k: '-132+76'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    comment: output = n*log10(input) + k
    k: '-avg_count_dB'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    comment: output = n*log10(input) + k
    k: '0'
    n: '20'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {state: disabled}
- name: blocks_probe_rate_1
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mode
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    Freq: freq
    Gain: gain
    Offset: gps_sig_offset
    _source_code: "\"\"\"\nEmbedded Python Blocks: REv C\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport requests\nimport json\nimport warnings\nfrom datetime import datetime\nwarnings.simplefilter(\"ignore\", np.ComplexWarning)\nfrom gps import *\n\n\n# import date.time  NG in Raspberry PI\n#from datetime import date\n# datetime object containing current date and time\nnow = datetime.now()\n#print(\"now =\", now)\n# dd/mm/YY H:M:S\ndt_string = now.strftime(\"%d/%m/%Y %H:%M:%S\")\nprint(\"Start Collection at: \", dt_string)\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block, sync_block\n    \"\"\"Embedded Python Block test case - count number and a simple multiply const\"\"\"\n\n    def __init__(self, file_name='log_my_rcvr_gps.csv',Freq=104.5e6,Gain=30,Offset= 39):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='WA1CYB GPS Python Block',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n            #out_sig=[np.float32, np.byte]\n        self.rcvr_file_name = file_name #rcvr_file_name\n        rcvr_file_name = file_name \n        self.message_port_register_in(pmt.intern('msg_in_attach'))\n        self.message_port_register_in(pmt.intern('gps_nmea_in'))        \n        portName1 = 'gps_msg_out'\n        self.message_port_register_out(pmt.intern(portName1))\n        portName2 = 'time_and_dBm_out'\n        self.message_port_register_out(pmt.intern(portName2))\n        self.set_msg_handler(pmt.intern('msg_in_attach'), self.handle_msg)\n        self.set_msg_handler(pmt.intern('gps_nmea_in'), self.handle_gps_msg)\n                \n        self.message_port_register_out(pmt.intern('clear_input'))\n        self.portName1 = portName1\n        self.portName2 = portName2        \n        self.dt_string = dt_string\n        self.msg = \"Hello\"\n        self.gps_msg = \"There\" \n        self.nmea = self.gps_msg\n        gpsd = gps(mode=WATCH_ENABLE|WATCH_NEWSTYLE)  #WATCH_NEWSTYLE forces JSON streaming\n        self.gpsd = gpsd\n#        print(\"gpsd_TOP =\", gpsd)\n        #ipadr= \"127.0.0.1\", myport= \"2947\",        \n#        self.ipadr = ipadr\n#        self.myport = myport\n        print(\"logFREQ=\", Freq, \"Gain=\", Gain, \"Offset=\", Offset, \"start time=\", dt_string)\n        #header_message = \"logFREQ= \"+ str(Freq)+ \" Gain= \" + str(Gain)+ \" Offset= \"+ str(Offset)+ \" start time= \"+ str(dt_string)\n        \n        with open(rcvr_file_name, \"a\") as f:\n            \n            f.write(\"logFREQ= ,\"+ str(Freq)+ \",Gain= ,\" + str(Gain)+ \",Offset= ,\"+ str(Offset)+ \",start time= ,\"+ str(dt_string) + \"\\n\")\n            f.write(\"Lattitude ,  Longitude,  Signal Level (dB), Time\" + \"\\n\")\n       \n        self.value = 1\n#        self.url = 'http://192.168.0.123:2947'\n\n        \n    def handle_msg(self, msg):   # added input text notes to the file !\n        global textboxValue\n        textboxValue = pmt.symbol_to_string (msg)\n        self.textboxValue = textboxValue\n#        print (pmt.serialize_str (msg))       \n         \n    def handle_gps_msg(self, gps_msg):   # added input text notes to the file !\n        global nmea\n        nmea = pmt.deserialize_str (gps_msg)\n        self.gps_msg = nmea\n        self.nmea = nmea\n#        print(\"NMEA Message = \", nmea)\n#        global PMT_msg\n  #@      PMT_msg = pmt.to_pmt([self.local_save])\n        \n    def work(self, input_items, output_items):\n        \"\"\"example output\"\"\"\n        global textboxValue\n        msg = self.msg\n        gps_msg = self.gps_msg\n        portName1 = self.portName1\n        portName2 = self.portName2\n        textboxValue = self.textboxValue   # a string type\n        rcvr_file_name = self.rcvr_file_name\n        nmea = self.nmea\n        gpsd = self.gpsd\n#        print(\"gpsd_MID =\", gpsd)\n#        gpsd = gps(mode=WATCH_ENABLE|WATCH_NEWSTYLE)\n#        print('latitude\\tlongitude\\ttime utc\\t\\t\\taltitude\\tepv\\tept\\tspeed\\tclimb') # '\\t' = TAB to try and output the data in columns.\n        report = gpsd.next() #\n#        print(report) # prints the raw data NOT in NEMA format !\n\n        if report['class'] == 'TPV':\n# typical 2022-09-11T15:52:20.000Z \t 114.5752 \t 38.884 \t 0.005 \t 0.167 \t 0.058 \t 42.460212246 \t -71.530672654 \n#            print(\"TPV found\")\n            nmea = self.nmea #\"print(\"nmea received\", \"textboxValue = \", textboxValue) \"\n   #         print(getattr(report,'lat',0.0),\"\\t\", end=\" \")\n    #        print(getattr(report,'lon',0.0),\"\\t\", end=\" \")\n#            print(getattr(report,'time',''),\"\\t\") #, end=\" \")\n#            print(getattr(report,'alt','nan'),\"\\t\", end=\" \")\n#            print(getattr(report,'epv','nan'),\"\\t\", end=\" \")\n#            print(getattr(report,'ept','nan'),\"\\t\", end=\" \")\n #           print(getattr(report,'speed','nan'),\"\\t\")\n#            print(getattr(report,'climb','nan'),\"\\t\", end=\" \")\n#        time.sleep(.5)        \n\n \n        with open(rcvr_file_name, \"a\") as f:\n\n\n            for index in range(len(input_items[0])):     #value = 22.7712   # from the receiver and offset\n                self.value = (input_items[0][index])   # get the dB value\n                value = self.value\n\n                \n                a1 = getattr(report,'time', ' ')\n                a2 = getattr(report,'lat',0.0)\n                a3 = getattr(report,'lon',0.0)\n                a4 = value\n                print(a2,  a3, \"  \", a4)\n#                print(\"   \", str(a4))\n                gps_msg_to_send = str(a2) + \", \" + str(a3) + \", \" + str(a4) + \", \" + str(a1) \n                # (getattr(report,'time', ' '), getattr(report,'lat',0.0),\" \", getattr(report,'lon',0.0),\" \") #, \"{:.2f}\".format(value), \"dB\")\n#                print(gps_msg_to_send)               \n                msg_to_send = gps_msg_to_send \n                              \n                if len(textboxValue) >=1 :\n                    f.write(gps_msg_to_send + \"\\n\" + \", , , ,\" + textboxValue + \"\\n\")\n                    print(textboxValue)\n\n                else:\n                    f.write(gps_msg_to_send + \"\\n\")\n#                    print(\"un-changed\", textboxValue)\n                    \n                now = datetime.now()\n                dt_string = now.strftime(\"%d/%m/%Y %H:%M:%S\")\n                dt_dBm_string = dt_string + \" dB=\" + str(\"{:.2f}\".format(value))\n ###               print(dt_dBm_string)\n##                dt_dBm_bytes = str.encode(dt_dBm_string)       # # my_str_as_bytes = str.encode(my_str)\n##                print(\"byte stream: \", dt_dBm_bytes)\n                if len(textboxValue) >=1 :\n                    self.message_port_pub(pmt.intern(portName1), pmt.intern(msg_to_send + \"\\n\" + textboxValue))              \n                    self.message_port_pub(pmt.intern(portName2), pmt.intern(dt_dBm_string + \"\\n\" + textboxValue))\n\n                else:\n                    self.message_port_pub(pmt.intern(portName1), pmt.intern(msg_to_send))\n                    self.message_port_pub(pmt.intern(portName2), pmt.intern(dt_dBm_string))\n                    #output_items[0][index] = dt_dBm_bytes\n\n      \n        output_items[0][:] = input_items[0]\n#        output_items[1][:] = msg_to_send_bytes\n        # clear input line\n        textboxValue = \"\"\n        self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))\n        return len(output_items[0])\n \n\n"
    file_name: rcvr_file_name
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-2.5e3'
    comment: LSB  Tuned 2.5 kHz low in Frequency
    decim: '1'
    samp_rate: baseband_rate
    taps: lsb_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rit
    decim: '1'
    samp_rate: baseband_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate/1)
    bbdc: 'True'
    buffer_size: '32768'
    comment: |-
      ip:192.168.2.1
      'usb:3.6.5'

      run:
      iio_attr -a -d to get context
    filter_source: '''Auto'''
    frequency: int(freq+rit)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate/1)
    type: fc32
    uri: uri
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: 200 kHz BP Filter
    cutoff_freq: 100e3
    decim: 4*1
    gain: '1'
    samp_rate: samp_rate/1
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Coarse 16 kHz BW Filter (8 kHz LPF)

      1.087 makes up for filter loss(s)
    cutoff_freq: '8000'
    decim: '1'
    gain: '1.087'
    samp_rate: samp_rate/4
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Fine 400Hz BW Filter (200Hz LPF)
      Width allows for some SDR Drift over collection of a CW signal
    cutoff_freq: '400'
    decim: int(16*2)
    gain: 16*2
    samp_rate: samp_rate/4
    type: fir_filter_ccf
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: 384 kHz BPF in 24 kHz out
    cutoff_freq: 8e3
    decim: int((samp_rate/4)/baseband_rate)
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_1
  id: note
  parameters:
    note: LSB
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: USB
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: USB
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: LSB
  states: {}
- name: note_1_1_0
  id: note
  parameters:
    note: NBFM
  states: {}
- name: note_1_1_0_0
  id: note
  parameters:
    comment: (good for audio)
    note: WBFM - with Limited Audio Bandwidth
  states: {}
- name: note_2
  id: note
  parameters:
    note: AM(ENV)
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: AM(Syncronous)
  states: {}
- name: note_3
  id: note
  parameters:
    note: ~ S meter
  states: {}
- name: note_8
  id: note
  parameters:
    note: NBFM Rcv 24Ksps
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 3,0,1,4
    is_pair: 'False'
    label: Add Notes to the file in real time (with Enter Key)
    type: string
    value: Start
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/4
    fc: freq+rit
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,4
    label1: Input
    label2: Pre-Filtered Log Input
    name: '"Received Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.20'
    ymax: '-20'
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/4/32
    fc: freq
    fftsize: '1024'
    gui_hint: 6,0,1,4
    label1: Logging Bandwidth
    label2: Pre-Filtered Log Input
    name: '"Fine Tune"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    label1: S Meter
    max: '0'
    min: '-174+40'
    name: ''
    type: float
    unit1: dB relative
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,1,1
    label1: Log Level (delayed)
    max: '115'
    min: '-15'
    type: float
    unit1: dB
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    color1: ("black", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,1,1
    label1: Log Level (delayed)
    max: '115'
    min: '-15'
    type: float
    unit1: dB
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq+rit
    fftsize: '2048'
    gui_hint: 7,0,1,4
    name: ''
    plotconst: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: LPF Re
    name: '"Not Averaged"'
    size: 24000*2
    srate: int(samp_rate/32)
    type: float
    ymax: '0'
    ymin: '-140'
    yunit: '"dB"'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_5
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq+rit*0
    comment: |-
      Sample Rate Options for RTL-SDR
        250e3
      1024e3
      1536e3  32*48e3
      1792e3
      1920e3  40*48e3
      2048e3
      2160e3 45*48e3
      2560e3
      2880e3 60*48e3
      3200e3
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq+rit
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sd_spec0: A:A
    stream_args: find=all
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 3e6
    center_freq0: freq
    comment: |-
      DEVICE ADDRESS:
      "addr=192.168.0.8"
      "find_all=1"
    dev_addr: '"find_all=1"'
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rit_agc
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: probe
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rit_agc
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: probe
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rit_agc
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    comment: at samp_rate/4
    stream_id: probe
  states: {}
- name: zeromq_pull_msg_source_0_1
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://" + ip_adr_in + ":" + str(port_in)'
    comment: |-
      "tcp://" + ip_adr_in + ":" + str(port_in)
      "tcp://localhost:" + str(port_in)
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [analog_const_source_x_1, '0', qtgui_number_sink_0, '0']
- [analog_fastnoise_source_x_0, '0', low_pass_filter_0, '0']
- [analog_fastnoise_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fastnoise_source_x_1, '0', blocks_multiply_const_ft1, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_0, '4']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_selector_0, '1']
- [band_pass_filter_0, '0', blocks_selector_0, '0']
- [band_pass_filter_1, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_2, '0', blocks_add_xx_1, '0']
- [band_pass_filter_2_0, '0', blocks_add_xx_1, '1']
- [blocks_add_const_vxx_0, '0', epy_block_0_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_0, '2']
- [blocks_complex_to_real_0_0, '0', blocks_selector_0, '3']
- [blocks_complex_to_real_2, '0', band_pass_filter_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_multiply_const_ft1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_5, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_2, '0']
- [blocks_nlog10_ff_0, '0', probe_signal, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink_1_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_1, rate, blocks_message_debug_1_0_0, print]
- [blocks_repeat_0, '0', blocks_probe_rate_1, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_probe_rate_0, '0']
- [epy_block_0_0, '0', blocks_null_sink_0, '0']
- [epy_block_0_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0_0, clear_input, qtgui_edit_box_msg_1, val]
- [epy_block_0_0, time_and_dBm_out, blocks_message_debug_1_0, print]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', virtual_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_mag_1, '0']
- [low_pass_filter_0_0_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_1, '0', freq_xlating_fir_filter_xxx_1, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_1, '1']
- [qtgui_edit_box_msg_1, msg, epy_block_0_0, msg_in_attach]
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_5, '0', audio_sink_0_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', analog_pll_refout_cc_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_2, '0']
- [virtual_source_0, '0', band_pass_filter_2_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0_0, '0', band_pass_filter_1, '0']
- [virtual_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0_0_1, '0', low_pass_filter_0_0, '0']
- [zeromq_pull_msg_source_0_1, out, epy_block_0_0, gps_nmea_in]

metadata:
  file_format: 1
  grc_version: 3.10.2.0
